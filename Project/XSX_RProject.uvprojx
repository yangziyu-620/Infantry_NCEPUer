# Keil uVision project XSX_RProject.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XSX_RProject +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --C99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\SYSTEM;..\mpu6050;..\mpu6050\eMPL;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\TASK;..\TIMER_TASK;.\AppInfo;..\Project
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c system.c remote.c stm32f4xx_it.c control.c kalman.c kalman_filter.c crc.c magazine.c friction.c super_cap.c
  group BSP
    ../BSP/: can1.c can2.c usart2.c pwm.c led.c laser.c usart4.c usart5.c adda.c iwdg.c
  group TASK
    ../TASK/: Task_Start.c Task_Chassis.c Task_Revolver.c Task_Gimbal.c
  group AppInfo
    ./AppInfo/: Info_Update.c Info_Transmitter.c
    ../APP/: judge.c vision.c
    ./: vison2.c
  group TIMER_TASK
    ../TIMER_TASK/: Timer_Send_Task.c
  group SYSTEM
    ../SYSTEM/: usart.c sys.c delay.c
    ../Libraries/cmsis/: system_stm32f4xx.c
    ../Libraries/startup/: startup_stm32f40xx.s
  group MPU6050
    ../mpu6050/: myiic.c mpu6050.c MPU_Temperature.c
    ../mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dac.c stm32f4xx_iwdg.c
  group Drivers/CMSIS
    ../Libraries/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group README
    ./readme/: readme.txt
